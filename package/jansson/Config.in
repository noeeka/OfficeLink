## package/jansson/Config.in
```kconfig
config BR2_PACKAGE_JANSSON
	bool "jansson"
	help
	  Standard GNU compressor.  Provides jansson.
```
